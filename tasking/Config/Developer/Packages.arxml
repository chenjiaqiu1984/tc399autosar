<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="56375202-ADFF-49D1-AAD8-556406AA1236">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="BE4F8937-A0EC-44D4-9DF7-732B2CB46A40">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9E21A394-2132-4EDC-B952-C310CF194F16">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D2C8C01D-B931-4F98-BA87-F85B670E0BBD">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9E0A7976-764F-4B0E-B8A6-B7D55003366E">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="87235DB5-B304-4521-85AF-31C1245B5501">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4A8B9369-C870-4596-9A34-241A2AC14C39">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C73E875B-4945-4D3F-8EFC-BC5A071B1AB7">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8186953C-6048-4A95-9D72-588DAA0CA0FB">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="30062D44-3B2D-4F53-A3C0-C93A68AA6365">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C9B910D1-3F4A-4047-B88B-6D3B36D9D736">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4411814D-D58A-4B67-8BE8-08B0940F6929">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="892BD2C5-945C-46DF-A650-FA407883DD49">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4ADAE325-B1B8-4F0F-AF48-F2AA0DFA0F04">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EAE8CFA8-1082-4F2E-8E78-D6656387FCBD">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4C2C3293-1FF8-4B29-824A-DAE31FC2C0A9">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="697B2B63-65FC-45D6-91B7-C9EAC89B7EB2">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C5393525-ABE0-4A39-98EA-BEEECB2B1863">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9A76D0B5-3EEB-4364-8ABD-F7832567E7A3">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BC4BB8F0-73AF-4520-A931-BB447ABB9400">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5C71F7DB-6813-4CE1-97D8-3F56816EEAD6">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D9A502DD-3974-4EB3-BD77-7BA3076173FC">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A38B793-5BC5-4394-AA64-C881D418FF59">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4D08229B-69A7-4921-A2D3-F409C8004BC4">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EBD2D2D2-432E-4CDF-A4BD-E4758CE3402A">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="68F8D99B-AA96-4A83-BA8B-0AE5F7664DC0">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C4CB930E-7C77-4E65-BFAA-7A3A87BA99D8">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="8774E67B-DC53-48D9-B54D-6F4E6467CE74">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C7BD4DFA-82D2-4BE0-BB04-C30E430B9D49">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="31D4B144-4E73-4C3F-8D19-59B3C996216F">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D9CC6064-B4E9-48B2-A242-3BEBDC5F1017">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="27956738-42B1-49BA-9AA0-F090B4C8983C">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0519099C-2773-4569-9191-610F4D4519CB">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5EAAD398-E9A5-4391-B01D-3DB1AB205230">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C8854618-4D4A-44D6-AD13-10081CB287DB">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1CEED126-EEBB-450E-89C9-A572F8503F48">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8CC420CE-8375-41BA-B068-8D48AED8DD10">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="03932C34-61CE-4815-826A-EF43A96F7E4A">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3B26A768-E4A4-4124-BF0C-9462C329E1DA">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DA52378A-B2A9-453D-BB5B-1135E164BA5B">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6E02F4AA-42CE-493A-A8BD-C95FBD4C79CD">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="95309B25-00FB-4E41-9A5B-78F5FA25784F">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6173EF17-F9DE-4BD1-B899-AE181007DC8F">
      <SHORT-NAME>DataTransformations</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4F83437F-D558-4B5A-9B37-50A130AFB99D">
      <SHORT-NAME>SecureCommunicationPropsSet</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="20A7C73A-EC46-4FE0-933E-B6179FDD6919">
      <SHORT-NAME>SWC</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0FF93AB8-E911-4A90-981E-CA232C97096A">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D5E2E8CC-67F6-49D3-B7A9-0FE50B64CEA0">
          <SHORT-NAME>Constraint</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="288720A9-0922-4DA9-BB56-025BF9123EFE">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A4A31845-DC0F-4EF2-9E33-604B04457509">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="84714ED8-1AAE-45B3-B206-574DF5F25A70">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>